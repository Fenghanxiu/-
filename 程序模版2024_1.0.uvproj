# Keil uVision project 程序模版2024_1.0.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 程序模版2024_1.0 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c main.h hardware.c hardware.h iic.c iic.h onewire.c onewire.h ds1302.c ds1302.h echo.c echo.h uart.c uart.h
